# IAR project LSZH_V20_FLASH.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2368 NXP LPC2368
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; ..\BSP\; ..\Device\include; ..\Device\tcpip\INCLUDE; ..\user\; ..\user\user_debug\; ..\user\user_mem\; ..\user\user_option\; ..\user\user_flash; ..\..\..\..\..\uC-CPU; ..\..\..\..\..\uC-LCD\Source; ..\..\..\..\..\uC-CPU\ARM\IAR; ..\..\..\..\..\uC-LIB; ..\..\..\..\..\uCOS-II\Source; ..\..\..\..\..\uCOS-II\Ports\ARM\Generic\IAR; ..\..\..\..\..\uCOSView\Source; ..\..\..\..\..\uCOSView\Ports\ARM7\LPC2378\IAR
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LSZH_V20_FLASH_V3.06.bin
  ILINK.IlinkOutputFile: LSZH_V20_FLASH.out
  ILINK.IlinkIcfFile: ..\BSP\LPC2378_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: ZK_V11.23.bin
  ILINK.IlinkIcfFile: ..\BSP\LSZH_V20_Relase.icf
  group APP
    ../user/: includes.h main.c main.h os_cfg.h
    ./: 任务、中断.txt
  group BSP
    ../BSP/: cstartup.s LPC2378_Flash.icf LPC23xx.h LSZH_V20_Relase.icf target.c target.h
  group Device
    ../Device/18B20/: 18B20.c
    ../Device/PT2258/: CD22M3494.C PT2258.C
    ../Device/IIS/: dma.c i2s.c TMS320AIC23.c Use_Sound.c
    ../Device/HW/: hw.c
    ../Device/IIC/: I2C0INT.c I2C1INT.c
    ../Device/IO/: io.c
    ../Device/Realtime/: RealTime.c
    ../Device/SPI/: SC16IS752.c
    ../Device/UART/: uart.c
  group Device/Api
    ../Device/tcpip/API/: os_api.c
  group Device/TCP/IP/ARP
    ../Device/tcpip/ARP/: ARP.C
  group Device/TCP/IP/HARDWARE
    ../Device/tcpip/ETHERNET/: Ethernet.c
    ../Device/tcpip/HARDWARE/: Hardware_int.c
  group Device/TCP/IP/ICMP
    ../Device/tcpip/PING/: ICMP.C
  group Device/TCP/IP/IP
    ../Device/tcpip/IP/: IP.C
  group Device/TCP/IP/UDP
    ../Device/tcpip/UDP/: Udp.c
  group uC/CPU
    ../../../../../uC-CPU/ARM/IAR/: cpu.h cpu_a.s
    ../../../../../uC-CPU/: cpu_def.h
  group uC/LIB
    ../../../../../uC-LIB/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uCOS-II/Port
    ../../../../../uCOS-II/Ports/ARM/Generic/IAR/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_dcc.c
  group uCOS-II/Source
    ../../../../../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group User
    ../user/user_flash/: LP2368_FLASH.c LP2368_FLASH.h
    ../user/User_Option/: Lszh_hardware.h Lszh_msg.h PelcoD.c PelcoD.h Use_key.c Use_key.h User_DW.c User_DW.h User_on_msg.c user_on_msg.h User_option.c User_option.h User_power.c User_power.h User_Run.c User_table.c User_table.h User_TB.c User_TB.h User_udp.c User_udp.h User_XCOM.c User_XCOM.h
    ../user/user_debug/: user_debug.c user_debug.h
    ../user/user_mem/: user_mem.c User_mem.h
